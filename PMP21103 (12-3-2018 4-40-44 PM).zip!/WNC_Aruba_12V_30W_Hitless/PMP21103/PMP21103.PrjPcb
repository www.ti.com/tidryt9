# Altium project PMP21103.PrjPcb (part 2 of 2)

## Sheet PMP21103_RevB_SH3.SchDoc: PoE/AUX Switching
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 3; Revision: Use project parameter SCH_Rev; SheetNumber: 3; SheetTotal: 3; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C40  ValueDisplayed: 10µF  Value2: 25V  [1210_220]  (hidden comment: 885012209028)
C41  ValueDisplayed: 1µF  Value2: 25V  [0805_HV]  (hidden comment: GRM21BR71E105KA99L)
C42  VDC_V: 100V  ValueDisplayed: 1000pF  [0603]  (hidden comment: GRM188R72A102KA01D)
C43  VDC_V: 100V  ValueDisplayed: 1000pF  [0603]  (hidden comment: GRM188R72A102KA01D)
C44  ValueDisplayed: 0.01µF  [0603L]  (hidden comment: C1608X7R1H103K080AA)
D17  MMSD4148T1G  [SOD-123]
D18  MMSZ5231B-7-F  value 5.1V  [SOD-123]
D19  MMSD4148T1G  [SOD-123]
D24  PDS835L-13  [POWERDI5]
D25  PDS835L-13  [POWERDI5]
J6  ED555/2DS  [TERM_BLK_ED555-2DS]  (value not drawn)
J7  ED555/2DS  [TERM_BLK_ED555-2DS]  (value not drawn)
L7  MPZ2012S300AT000  [MPZ2012]
L8  744273801  value 9uH  ValueDisplayed: 9µH  [WE-SL5_HC]
L9  MPZ2012S300AT000  [MPZ2012]
Q15  CSD25402Q3A  [DNH0008A_NV]
Q16  CSD25402Q3A  [DNH0008A_NV]
Q17  2N7002P,215  [SOT-23]
Q18  BSH201,215  [SOT-23]
Q19  BSS123  [SOT-23]
Q20  2N7002P,215  [SOT-23]
Q21  2N7002P,215  [SOT-23]
R63  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R64  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R65  ValueDisplayed: 10.0k  [0603L]  (hidden comment: CRCW060310K0FKEA)
R66  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R67  ValueDisplayed: 20.0k  [0603L]  (hidden comment: CRCW060320K0FKEA)
R68  ValueDisplayed: 100k  [0603L]  (hidden comment: CRCW0603100KFKEA)
R69  ValueDisplayed: 12.7k  [0603]  (hidden comment: CRCW060312K7FKEA)
R70  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R71  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R74  Value2: 0.125W  ValueDisplayed: 2.49k  [0805_HV]  (hidden comment: CRCW08052K49FKEA)
R75  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
R76  ValueDisplayed: 4.99k  [0603L]  (hidden comment: CRCW06034K99FKEA)
U8  TPS3803-01DCKR  [DCK0005A_N]

### Nets
GND: C40.2 C41.2 C43.2 C44.1 D18.2(A) J6.1 L9.1 Q17.2(S) Q19.2(S) Q20.2(S) Q21.2(S) R69.1 R76.1 U8.2(GND)
12V_AUX: C43.1 D25.1(A) D25.2(A) L7.1 Q16.1(D) Q16.2(D) Q16.3(D) R68.1 ; off-sheet 12V_AUX
12V_POE: D24.1(A) D24.2(A) Q15.1(D) Q15.2(D) Q15.3(D) R75.2 ; off-sheet 12V_POE
VOUT: C40.1 C41.1 D19.2(A) D24.3(K) D25.3(K) J6.2 Q15.5(S) Q15.6(S) Q15.7(S) Q15.8(S) Q15.9(S) Q16.5(S) Q16.6(S) Q16.7(S) Q16.8(S) Q16.9(S) R63.2 R70.1 ; off-sheet VOUT
VSB: D17.2(A) ; off-sheet VSB
VT: Q17.1(G) Q18.3(D) Q21.1(G) ; off-sheet VT
NetC42_1: C42.1 J7.2 L8.4 R74.2
NetC42_2: C42.2 J7.1 L8.3 R74.1
NetC44_2: C44.2 D18.1(K) R65.1 R67.1 U8.4(VDD)
NetD17_1: D17.1(K) D19.1(K) Q18.2(S) R65.2 R66.1
NetL7_2: L7.2 L8.1
NetL8_2: L8.2 L9.2
NetQ15_4: Q15.4(G) R64.2 R70.2
NetQ16_4: Q16.4(G) R63.1 R71.2
NetQ17_3: Q17.3(D) R71.1
NetQ18_1: Q18.1(G) Q19.3(D) R66.2
NetQ19_1: Q19.1(G) R67.2 U8.3(~{RESET})
NetQ20_1: Q20.1(G) Q21.3(D) R75.1 R76.2
NetQ20_3: Q20.3(D) R64.1
NetR68_2: R68.2 R69.2 U8.5(SENSE)

Not connected (* = marked no-connect by the designer): U8 1(NC)

### Notes on the sheet
- (near J6) 12V@2.5A OUT
- (near J6) GND
- ADDITIONAL EMI FILTERING
- MAY BE REQUIRED
- (near J7) GND
- (near J7) 12V@2.5A AUX IN
- FOR DIODE ORING:
- POPULATE:  D24, R25, R72
- DO NOT POPULATE:  R43, R44, R46, R47, R51, R52, R57, R63, R64, R65, R66, R67, R68, R69, R70, R71, R75, R76
- DO NOT POPULATE:  C30, C31, C44, D14, D17, D18, D19, U8
- DO NOT POPULATE:  Q11, Q12, Q13, Q14, Q15, Q16, Q17, Q18, Q19, Q20, Q21

### Library data of the parts
C40 = 885012209028: CAP, CERM, 10 µF, 25 V,+/- 10%, X7R, 1210; Manufacturer: Wurth Elektronik; Polarized: N; CompType: Capacitor; Value: 10uF; U/M: EA; Cap_F: 0.00001; Tolerance_%: 10; VDC_V: 25; TaMin_C: -55; TaMax_C: 125; Cap_Case: 1210; SizeArea_mm2: 8; SizeAreaWB_mm2: 14.7; SizeX_mm: 3.2; SizeY_mm: 2.5; SizeZ_mm: 2.2; AEC Category: Q200
C41 = GRM21BR71E105KA99L: CAP, CERM, 1 µF, 25 V, +/- 10%, X7R, 0805; Manufacturer: MuRata; Polarized: N; CompType: Capacitor; Value: 1uF; U/M: EA; Cap_F: 0.000001; Tolerance_%: 10; Value1: Unknown; VDC_V: 25; TaMin_C: -55; TaMax_C: 125; Cap_Case: 0805; SizeArea_mm2: 2.5; SizeAreaWB_mm2: 6.75; SizeX_mm: 2; SizeY_mm: 1.25; SizeZ_mm: 1.45; AEC Category: Q200
C42 C43 = CMP-0007467-2: CAP, CERM, 1000 pF, 100 V, +/- 10%, X7R, 0603; Manufacturer: MuRata; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 4.68; Value1: Unknown; U/M: EA; Value: 1000pF; TaMax_C: 125°C; SizeZ_mm: 1; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeArea_mm2: 1.28; Cap_F: 1nF; AEC Category: Q200
C44 = C1608X7R1H103K080AA: CAP, CERM, 0.01 µF, 50 V, +/- 10%, X7R, 0603; Manufacturer: TDK; Polarized: N; CompType: Capacitor; Value: 0.01uF; U/M: EA; Cap_F: 0.00000001; Tolerance_%: 10; ESR_ohm: 0.0539; Value1: 0.0539 ohm; VDC_V: 50; Value2: 50V; TaMin_C: -55; TaMax_C: 125; Cap_Case: 0603; SizeArea_mm2: 1.28; SizeAreaWB_mm2: 4.68; SizeX_mm: 1.6; SizeY_mm: 0.8; SizeZ_mm: 1; AEC Category: Q200
D17 D19 = MMSD4148T1G: Diode, Switching, 100 V, 0.2 A, SOD-123; Manufacturer: ON Semiconductor; Value: 100V; U/M: EA; Vf_V: 1; Value1: 0.2A; Value2: 1V; Io_A: 0.2; Vr_V: 100; TJmax_C: 150; SizeAreaWB_mm2: 13.095; SizeArea_mm2: 6.545; SizeX_mm: 3.85; SizeY_mm: 1.7; SizeZ_mm: 1.35; AEC Category: Q101
D18 = MMSZ5231B-7-F: Diode, Zener, 5.1 V, 500 mW, SOD-123; Manufacturer: Diodes Inc.; SymbolCreator: a0412235; U/M: EA; Power_W: 0.5; Vz_V: 5.1; Value1: 0.5W; RJA_CperW: 350; SizeAreaWB_mm2: 13.095; SizeArea_mm2: 6.545; SizeX_mm: 3.85; SizeY_mm: 1.7; SizeZ_mm: 1.35; AEC Category: Q101
D24 D25 = CMP-0076913-1: Diode, Schottky, 35 V, 8 A, PowerDI5; Manufacturer: Diodes Inc.; SizeAreaWB_mm2: 49.56; Vr_V: 35V; SizeArea_mm2: 24.96; TJmax_C: 125°C; AEC Category: Q101; Value: 35V; SizeZ_mm: 1.05; Green_REACh: Incomplete; Io_A: 8A; Vf_V: 4.6dV; SizeY_mm: 3.9; Value2: 0.46V; Green_Lifecycle: Not Set; U/M: EA; SizeX_mm: 6.4
J6 J7 = CMP-0074913-1: Terminal Block, 3.5mm Pitch, 2x1, TH; Manufacturer: On-Shore Technology; Cert_VDE: Y; CNHeader: False; Current_A: 6A; Green_Lifecycle: Active; Shrouded: N; Gender: Female; Green_REACh: Passed; Voltage_V: 150V; Row_Count: 1; Pitch_mm: 3.5; ContactFinish: Brass; CT: True
L7 L9 = CMP-0003428-2: Ferrite Bead, 30 ohm @ 100 MHz, 6 A, 0805; Manufacturer: TDK; ZTyp@100MHz_Ohm: 30; SizeAreaWB_mm2: 6.75; DCR_ohm: 0.01; Value1: 0.01 ohm; Value: 30 ohm; Imax_A: 6A; SizeZ_mm: 1.45; SizeX_mm: 2; SizeY_mm: 1.25; SizeArea_mm2: 2.5
L8 = CMP-0078807-1: Coupled inductor, 9 µH, 0.011 ohm, SMD; Manufacturer: Wurth Elektronik; DCR_ohm: 0.011; AEC Qualified: N; AEC Category: Q200
Q15 Q16 = CMP-0000025-2: MOSFET, P-CH, -20 V, -15 A, DNH0008A (VSONP-8); Alternate Manufacturer: None; Manufacturer: Texas Instruments; SizeZ_mm: 0.9; ChType: P; Value2: 7.5 nC; Value1: 0.007; VdsMax_V: -20V; SizeX_mm: 3.3; Vgs_V: -12V; Value: -20V; Rdson45_ohm: 7.7m; SizeArea_mm2: 10.89; AEC Category: Q101; IdsMax_A: -15A; SizeAreaWB_mm2: 18.49; U/M: EA; QgTyp_nC: 7.5
Q17 Q20 Q21 = 2N7002P,215: MOSFET, N-CH, 60 V, 0.36 A, SOT-23; Manufacturer: Nexperia; Alternate Manufacturer: None; U/M: EA; ChType: N; Value: 60V; VdsMax_V: 60; Value1: 2 ohm; Rdson45_ohm: 2; Value2: 0.6 nC; QgTyp_nC: 0.6; Vgs_V: 20; IdsMax_A: 0.36; SizeAreaWB_mm2: 14; SizeArea_mm2: 7.5; SizeX_mm: 2.5; SizeY_mm: 3; SizeZ_mm: 1.1; AEC Category: Q101
Q18 = BSH201,215: MOSFET, P-CH, -60 V, -0.3 A, SOT-23; Manufacturer: Nexperia; Alternate Manufacturer: None; U/M: EA; ChType: P; Value: -60V; Value1: 2.7 ohm; Rdson45_ohm: 2.7; Value2: 3 nC; QgTyp_nC: 3; Vgs_V: -20; SizeAreaWB_mm2: 14; SizeArea_mm2: 7.5; SizeX_mm: 2.5; SizeZ_mm: 1.1; AEC Category: Q101
Q19 = BSS123: MOSFET, N-CH, 100 V, 0.17 A, SOT-23; Manufacturer: Fairchild Semiconductor; Alternate Manufacturer: None; U/M: EA; ChType: N; Value: 100V; VdsMax_V: 100; Value1: 10 ohm; Rdson45_ohm: 10; Value2: 1.8 nC; QgTyp_nC: 1.8; Vgs_V: 20; IdsMax_A: 0.17
R63 R64 R66 R70 R71 R75 R76 = CRCW06034K99FKEA: RES, 4.99 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; CompType: Resistor; Value: 4.99k; Res_ohm: 4990; Value_Code: 4k99; Tolerance_%: 1; Power_W: 0.1; Value2: 0.1W; VDC_V: 75; TempCo: 100 ppm/C; SizeArea_mm2: 1.28; SizeX_mm: 1.6; SizeY_mm: 0.8; EIA_Code: E96; U/M: EA; AEC Category: Q200
R65 = CRCW060310K0FKEA: RES, 10.0 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; CompType: Resistor; Value: 10.0k; Res_ohm: 10000; Value_Code: 10k0; Tolerance_%: 1; Power_W: 0.1; Value2: 0.1W; VDC_V: 75; TempCo: 100 ppm/C; SizeArea_mm2: 1.28; SizeX_mm: 1.6; SizeY_mm: 0.8; EIA_Code: E96; U/M: EA; AEC Category: Q200
R67 = CRCW060320K0FKEA: RES, 20.0 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; CompType: Resistor; Value: 20.0k; Res_ohm: 20000; Value_Code: 20k0; Tolerance_%: 1; Power_W: 0.1; Value2: 0.1W; VDC_V: 75; TempCo: 100 ppm/C; EIA_Code: E96; U/M: EA; SizeArea_mm2: 1.28; SizeX_mm: 1.6; SizeY_mm: 0.8; AEC Category: Q200
R68 = CRCW0603100KFKEA: RES, 100 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; CompType: Resistor; Value: 100k; Res_ohm: 100000; Tolerance_%: 1; Power_W: 0.1; Value2: 0.1W; VDC_V: 75; TempCo: 100 ppm/C; SizeArea_mm2: 1.28; SizeX_mm: 1.6; SizeY_mm: 0.8; EIA_Code: E96; U/M: EA; AEC Category: Q200
R69 = CRCW060312K7FKEA: RES, 12.7 k, 1%, 0.1 W, 0603; Manufacturer: Vishay-Dale; CompType: Resistor; Value: 12.7k; Res_ohm: 12700; Value_Code: 12k7; Tolerance_%: 1; Power_W: 0.1; Value2: 0.1W; VDC_V: 75; TempCo: 100 ppm/C; SizeArea_mm2: 1.28; SizeX_mm: 1.6; SizeY_mm: 0.8; EIA_Code: E96; U/M: EA; AEC Category: Q200; Green_Lifecycle: Active; Green_REACh: Passed
R74 = CMP-0021116-2: RES, 2.49 k, 1%, 0.125 W, 0805; Manufacturer: Vishay-Dale; Power_W: 125mW; TempCo: 100 ppm/C; Value_Code: 2k49; U/M: EA; Value: 2.49k; EIA_Code: E96; SizeX_mm: 2; SizeY_mm: 1.25; SizeZ_mm: 1.45; SizeArea_mm2: 2.5; CompType: Resistor; VDC_V: 150V; AEC Category: Q200
U8 = CMP-0032337-1: Single Voltage Detector, 1 Supply Monitored, -40 to 85 degC, 5-pin SC70 (DCK), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Reset Threshold Accuracy(%): 1.5; # of Supplies Monitored: 1; VCC(Max)(V): 6; Iq(Typ)(uA): 3; Rating: Catalog; Output Driver Type / Reset Output: Active-low, Open-drain; SubFamily: Supervisor and Reset IC; VCC(Min)(V): 1.3; Threshold Voltage 1 (typ)(Typ)(V): Adjustable

## Nets that join several sheets
GND: PMP21103_RevB_SH1 (6 pins), PMP21103_RevB_SH2 (27 pins), PMP21103_RevB_SH3 (14 pins)
PGND: PMP21103_RevB_SH1 (6 pins), PMP21103_RevB_SH2 (27 pins)
12V_POE: PMP21103_RevB_SH2 (6 pins), PMP21103_RevB_SH3 (6 pins)
SS: PMP21103_RevB_SH1 (U4.13), PMP21103_RevB_SH2 (R35.1 R39.2 U7.15)
VCIN: PMP21103_RevB_SH1 (R14.2), PMP21103_RevB_SH2 (C15.2 L4.1)
VCOUT: PMP21103_RevB_SH1 (R1.1 R4.1 R6.1 R13.2), PMP21103_RevB_SH2 (C38.1 U7.13 U7.14)
VDD: PMP21103_RevB_SH1 (8 pins), PMP21103_RevB_SH2 (C17.1 L5.1 R34.2 R35.2)
VOUT: PMP21103_RevB_SH2 (R43.2), PMP21103_RevB_SH3 (18 pins)
VSB: PMP21103_RevB_SH2 (C31.1 Q11.2 R47.2), PMP21103_RevB_SH3 (D17.2)
VT: PMP21103_RevB_SH2 (Q12.1 Q14.1 R52.2 R57.2), PMP21103_RevB_SH3 (Q17.1 Q18.3 Q21.1)

## Assembly variants
001: not fitted D20 D21 D22 D23 D100 D101 R25 R34 R43 R101